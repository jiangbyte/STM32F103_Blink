# Keil uVision project Blink.uvprojx, settings and files
target Blink (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ../User;../CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT7: RAM 0x20000000 size 0x5000
  scatter file: .\Blink.sct
  group Startup
    ./: startup_stm32f103xb.s
  group User
    ../User/: main.c stm32f103xb.h
  group CMSIS
    ../CMSIS/: core_cm3.h
